# Keil uVision project ILI9163_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: ILI9163_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c ILI9163_lib.c Font16x16.h Colors.h Font32x50.h Delay_lib.h Delay_lib.c
